<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\R2_armx.ewp</path>
  </project>
  <batchBuild />
</workspace>
